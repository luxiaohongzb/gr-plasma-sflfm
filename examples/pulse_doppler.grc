options:
  parameters:
    generate_options: qt_gui
    id: untitled
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bandwidth
  id: variable
  parameters:
    value: '30000000.0'
  states: {}
- name: end_freq
  id: variable
  parameters:
    value: '3300000000.0'
  states: {}
- name: n_pulse_cpi
  id: variable
  parameters:
    value: '128'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '60000000.0'
  states: {}
- name: start_freq
  id: variable
  parameters:
    value: '3000000000.0'
  states: {}
- name: step
  id: variable
  parameters:
    value: '30000000.0'
  states: {}
- name: plasma_cw_to_pulsed_0
  id: plasma_cw_to_pulsed
  parameters:
    prf: 1e3
    prf_key: radar:prf
    samp_rate: samp_rate
    sample_rate_key: core:sample_rate
  states: {}
- name: plasma_freq_step_controller_0
  id: plasma_freq_step_controller
  parameters:
    cyclic: 'True'
    start_freq: start_freq
    step_freq: step
    stop_freq: end_freq
    tx_freq_key: core:tx_freq
  states: {state: disabled}
- name: plasma_ifft_range_profile_0
  id: plasma_ifft_range_profile
  parameters:
    backend: plasma.Device.CUDA
    bandwidth: 30e6
    depth: '100'
    dynamic_range: '60'
    freq_key: core:rx_freq
    n_fft_synthesis: '256'
    prf: 1e3
    pulse_width: '10e-6'
    sample_rate: samp_rate
    sweep_start: start_freq
    sweep_step: step
    sweep_stop: end_freq
  states: {}
- name: plasma_lfm_source_0
  id: plasma_lfm_source
  parameters:
    bandwidth: bandwidth
    bandwidth_key: radar:bandwidth
    duration_key: radar:duration
    label_key: core:label
    prf: '0'
    prf_key: radar:prf
    pulse_width: '10e-6'
    samp_rate: samp_rate
    sample_rate_key: core:sample_rate
    start_freq: '-bandwidth/2'
    start_freq_key: radar:start_freq
  states: {}
- name: plasma_pdu_file_sink_0
  id: plasma_pdu_file_sink
  parameters:
    data_filename: /home/mingliu/echo_data.dat
    meta_filename: /home/mingliu/Documents/gr-plasma/tools/data/test_1213/echo_data_meta
    save_meta: 'True'
    type: complex
  states: {state: disabled}
- name: plasma_pulse_doppler_0
  id: plasma_pulse_doppler
  parameters:
    backend: plasma.Device.CUDA
    depth: '100'
    doppler_fft_size_key: doppler_fft_size
    n_pulse_cpi: n_pulse_cpi
    nfft: n_pulse_cpi
  states: {state: disabled}
- name: plasma_pulse_to_cpi_0
  id: plasma_pulse_to_cpi
  parameters:
    n_pulse_cpi: n_pulse_cpi
    n_pulse_cpi_key: radar:n_pulse_cpi
  states: {state: disabled}
- name: plasma_range_doppler_sink_0
  id: plasma_range_doppler_sink
  parameters:
    center_freq: 2.4e9
    center_freq_key: core:tx_freq
    depth: '10'
    detection_indices_key: detection_indices
    dynamic_range: '60'
    dynamic_range_key: dynamic_range
    n_matrix_col_key: n_matrix_col
    nrow: n_pulse_cpi
    prf_key: radar:prf
    pulsewidth_key: radar:duration
    samp_rate: samp_rate
    samp_rate_key: core:sample_rate
  states: {state: disabled}
- name: plasma_sweep_collector_0
  id: plasma_sweep_collector
  parameters:
    freq_key: core:rx_freq
    output_dir: /home/mingliu/Documents/gr-plasma/tools/data/test5
    output_prefix: '"sweep"'
    save_cycles: '32'
    sweep_start: start_freq
    sweep_step: step
    sweep_stop: end_freq
  states: {}
- name: plasma_usrp_radar_0
  id: plasma_usrp_radar
  parameters:
    args: addr=192.168.40.2
    cal_file: ''
    clock_source: gpsdo
    elevate_priority: 'True'
    freq_mode: hop
    hop_end_freq: end_freq
    hop_start_freq: start_freq
    hop_step: step
    lo_stabilize_time: '1'
    rx_freq: 3e9
    rx_freq_key: core:rx_freq
    rx_gain: '10'
    samp_rate: samp_rate
    sample_start_key: core:sample_start
    start_delay: '0.5'
    time_source: gpsdo
    tx_freq: 3e9
    tx_freq_key: core:tx_freq
    tx_gain: '10'
    verbose: 'True'
  states: {}

connections:
- [plasma_cw_to_pulsed_0, out, plasma_usrp_radar_0, in]
- [plasma_lfm_source_0, out, plasma_cw_to_pulsed_0, in]
- [plasma_sweep_collector_0, out, plasma_ifft_range_profile_0, in]
- [plasma_usrp_radar_0, out, plasma_pdu_file_sink_0, in]
- [plasma_usrp_radar_0, out, plasma_sweep_collector_0, in]

metadata:
  file_format: 1
